<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>TrafficGen2</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>500</value></param>
</block>
<block>
<key>blocks_message_strobe_random</key>
<param><key>id</key><value>blocks_message_strobe_random_0</value></param>
<param><key>dist</key><value>blocks.STROBE_POISSON</value></param>
<param><key>mean</key><value>1000</value></param>
<param><key>msg</key><value>pmt.intern("TEST22")</value></param>
<param><key>std</key><value>1000</value></param>
</block>
<block>
<key>foo_periodic_msg_source</key>
<param><key>id</key><value>foo_periodic_msg_source_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>msg</key><value>pmt.intern("Hello World!")</value></param>
<param><key>num</key><value>5</value></param>
<param><key>interval</key><value>500</value></param>
<param><key>quit</key><value>True</value></param>
</block>
<block>
<key>lqe_contador</key>
<param><key>id</key><value>lqe_contador_0</value></param>
<param><key>maxValor</key><value>5</value></param>
</block>
<block>
<key>trafficgen_generator_constant</key>
<param><key>id</key><value>trafficgen_generator_constant_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>vbr_port</key><value>trafficgen.VBR_PORT_REQUEST_PACKET_INTERVAL</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>trafficgen_generator_gaussian</key>
<param><key>id</key><value>trafficgen_generator_gaussian_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>mean</key><value>0.5</value></param>
<param><key>multiplier</key><value>1000</value></param>
<param><key>std</key><value>0.1</value></param>
<param><key>vbr_port</key><value>trafficgen.VBR_PORT_REQUEST_BURST_DURATION</value></param>
</block>
<block>
<key>trafficgen_generator_poisson</key>
<param><key>id</key><value>trafficgen_generator_poisson_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>mean</key><value>0.1</value></param>
<param><key>multiplier</key><value>10</value></param>
<param><key>vbr_port</key><value>trafficgen.VBR_PORT_REQUEST_PACKET_INTERVAL</value></param>
</block>
<block>
<key>trafficgen_generator_uniform</key>
<param><key>id</key><value>trafficgen_generator_uniform_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>maximum</key><value>0.3</value></param>
<param><key>minimum</key><value>0</value></param>
<param><key>multiplier</key><value>1000</value></param>
<param><key>vbr_port</key><value>trafficgen.VBR_PORT_BURST_INTERVAL</value></param>
</block>
<block>
<key>trafficgen_receiver</key>
<param><key>id</key><value>trafficgen_receiver_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>logfile</key><value>/tmp/trafficgen_receiver.log</value></param>
</block>
<block>
<key>trafficgen_user_trigger</key>
<param><key>id</key><value>trafficgen_user_trigger_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>state</key><value>True</value></param>
</block>
<block>
<key>trafficgen_vbr_transmitter</key>
<param><key>id</key><value>trafficgen_vbr_transmitter_0</value></param>
<param><key>constant_value</key><value>2</value></param>
<param><key>content_type</key><value>trafficgen.CONTENT_SEQUENTIAL</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>logfile</key><value>/tmp/trafficgen_vbr_transmitter.log</value></param>
<param><key>sequential_maximum</key><value>255</value></param>
<param><key>sequential_minimum</key><value>0</value></param>
<param><key>use_acks</key><value>True</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>trafficgen_generator_poisson_0</sink_block_id><source_key>strobe</source_key><sink_key>Request</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_random_0</source_block_id><sink_block_id>lqe_contador_0</sink_block_id><source_key>strobe</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>foo_periodic_msg_source_0</source_block_id><sink_block_id>blocks_message_strobe_random_0</sink_block_id><source_key>out</source_key><sink_key>set_msg</sink_key></connection>
<connection><source_block_id>lqe_contador_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>trafficgen_generator_constant_0_0</source_block_id><sink_block_id>trafficgen_vbr_transmitter_0</sink_block_id><source_key>Value</source_key><sink_key>Packet Interval</sink_key></connection>
<connection><source_block_id>trafficgen_generator_gaussian_0</source_block_id><sink_block_id>trafficgen_vbr_transmitter_0</sink_block_id><source_key>Value</source_key><sink_key>Burst Duration</sink_key></connection>
<connection><source_block_id>trafficgen_generator_poisson_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>Value</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>trafficgen_generator_poisson_0</source_block_id><sink_block_id>trafficgen_vbr_transmitter_0</sink_block_id><source_key>Value</source_key><sink_key>Packet Size</sink_key></connection>
<connection><source_block_id>trafficgen_generator_uniform_0</source_block_id><sink_block_id>trafficgen_vbr_transmitter_0</sink_block_id><source_key>Value</source_key><sink_key>Burst Interval</sink_key></connection>
<connection><source_block_id>trafficgen_user_trigger_0</source_block_id><sink_block_id>trafficgen_vbr_transmitter_0</sink_block_id><source_key>trigger</source_key><sink_key>Trigger Start</sink_key></connection>
<connection><source_block_id>trafficgen_vbr_transmitter_0</source_block_id><sink_block_id>trafficgen_receiver_0</sink_block_id><source_key>PDU</source_key><sink_key>input</sink_key></connection>
<connection><source_block_id>trafficgen_vbr_transmitter_0</source_block_id><sink_block_id>trafficgen_generator_constant_0_0</sink_block_id><source_key>Request</source_key><sink_key>Request</sink_key></connection>
<connection><source_block_id>trafficgen_vbr_transmitter_0</source_block_id><sink_block_id>trafficgen_generator_gaussian_0</sink_block_id><source_key>Request</source_key><sink_key>Request</sink_key></connection>
<connection><source_block_id>trafficgen_vbr_transmitter_0</source_block_id><sink_block_id>trafficgen_generator_poisson_0</sink_block_id><source_key>Request</source_key><sink_key>Request</sink_key></connection>
<connection><source_block_id>trafficgen_vbr_transmitter_0</source_block_id><sink_block_id>trafficgen_generator_uniform_0</sink_block_id><source_key>Request</source_key><sink_key>Request</sink_key></connection>
</flow_graph>
