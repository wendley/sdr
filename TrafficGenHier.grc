<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>TrafficGenHier</value></param>
<param><key>generate_options</key><value>hb</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>trafficgen_cbr_transmitter</key>
<param><key>id</key><value>trafficgen_cbr_transmitter_0</value></param>
<param><key>constant_value</key><value>0</value></param>
<param><key>content_type</key><value>trafficgen.CONTENT_CONSTANT</value></param>
<param><key>distribution_type</key><value>trafficgen.DIST_UNIFORM</value></param>
<param><key>logfile</key><value>/tmp/trafficgen_cbr_transmitter.log</value></param>
<param><key>distribution_max</key><value>255</value></param>
<param><key>distribution_mean</key><value>127</value></param>
<param><key>distribution_min</key><value>0</value></param>
<param><key>packet_interval</key><value>1000</value></param>
<param><key>packet_size</key><value>1500</value></param>
<param><key>distribution_scale</key><value>1</value></param>
<param><key>distribution_shape</key><value>1</value></param>
<param><key>distribution_std</key><value>42</value></param>
<param><key>use_acks</key><value>True</value></param>
</block>
<block>
<key>trafficgen_time_trigger</key>
<param><key>id</key><value>trafficgen_time_trigger_0</value></param>
<param><key>active_time</key><value>1000</value></param>
<param><key>inactive_time</key><value>1000</value></param>
<param><key>initial_state</key><value>True</value></param>
</block>
<connection><source_block_id>trafficgen_cbr_transmitter_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>PDU</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>trafficgen_time_trigger_0</source_block_id><sink_block_id>trafficgen_cbr_transmitter_0</sink_block_id><source_key>trigger</source_key><sink_key>Trigger Start</sink_key></connection>
</flow_graph>
