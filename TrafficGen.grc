<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>TrafficGen</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>cb1</value></param>
<param><key>value</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>false</key><value>False</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>cb2</value></param>
<param><key>value</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>false</key><value>False</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>TrafficGenHier</key>
<param><key>id</key><value>TrafficGenHier_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>foo_periodic_msg_source</key>
<param><key>id</key><value>foo_periodic_msg_source_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>msg</key><value>pmt.intern("Hello World!")</value></param>
<param><key>num</key><value>1000</value></param>
<param><key>interval</key><value>100</value></param>
<param><key>quit</key><value>True</value></param>
</block>
<block>
<key>lqe_contador</key>
<param><key>id</key><value>lqe_contador_0</value></param>
<param><key>maxValor</key><value>numMsg</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>numMsg</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>trafficgen_cbr_transmitter</key>
<param><key>id</key><value>trafficgen_cbr_transmitter_0</value></param>
<param><key>constant_value</key><value>1</value></param>
<param><key>content_type</key><value>trafficgen.CONTENT_CONSTANT</value></param>
<param><key>distribution_type</key><value>trafficgen.DIST_UNIFORM</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>logfile</key><value>/tmp/trafficgen_cbr_transmitter.log</value></param>
<param><key>distribution_max</key><value>255</value></param>
<param><key>distribution_mean</key><value>127</value></param>
<param><key>distribution_min</key><value>0</value></param>
<param><key>packet_interval</key><value>25</value></param>
<param><key>packet_size</key><value>100</value></param>
<param><key>distribution_scale</key><value>1</value></param>
<param><key>distribution_shape</key><value>1</value></param>
<param><key>distribution_std</key><value>42</value></param>
<param><key>use_acks</key><value>True</value></param>
</block>
<block>
<key>trafficgen_generator_poisson</key>
<param><key>id</key><value>trafficgen_generator_poisson_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>mean</key><value>0.5</value></param>
<param><key>multiplier</key><value>1000</value></param>
<param><key>vbr_port</key><value>trafficgen.VBR_PORT_PACKET_SIZE</value></param>
</block>
<block>
<key>trafficgen_receiver</key>
<param><key>id</key><value>trafficgen_receiver_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>logfile</key><value>/tmp/trafficgen_receiver.log</value></param>
</block>
<block>
<key>trafficgen_time_trigger</key>
<param><key>id</key><value>trafficgen_time_trigger_0</value></param>
<param><key>active_time</key><value>1000</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>inactive_time</key><value>1000</value></param>
<param><key>initial_state</key><value>True</value></param>
</block>
<block>
<key>trafficgen_vbr_transmitter</key>
<param><key>id</key><value>trafficgen_vbr_transmitter_0</value></param>
<param><key>constant_value</key><value>0</value></param>
<param><key>content_type</key><value>trafficgen.CONTENT_CONSTANT</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>logfile</key><value>/tmp/trafficgen_vbr_transmitter.log</value></param>
<param><key>sequential_maximum</key><value>255</value></param>
<param><key>sequential_minimum</key><value>0</value></param>
<param><key>use_acks</key><value>True</value></param>
</block>
<block>
<key>trafficgen_user_trigger</key>
<param><key>id</key><value>trigger_start</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>state</key><value>cb1</value></param>
</block>
<block>
<key>trafficgen_user_trigger</key>
<param><key>id</key><value>trigger_stop</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>state</key><value>cb2</value></param>
</block>
<connection><source_block_id>foo_periodic_msg_source_0</source_block_id><sink_block_id>lqe_contador_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lqe_contador_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>trafficgen_cbr_transmitter_0</source_block_id><sink_block_id>lqe_contador_0</sink_block_id><source_key>PDU</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>trafficgen_cbr_transmitter_0</source_block_id><sink_block_id>trafficgen_receiver_0</sink_block_id><source_key>PDU</source_key><sink_key>input</sink_key></connection>
<connection><source_block_id>trafficgen_time_trigger_0</source_block_id><sink_block_id>trafficgen_cbr_transmitter_0</sink_block_id><source_key>trigger</source_key><sink_key>Trigger Start</sink_key></connection>
<connection><source_block_id>trigger_start</source_block_id><sink_block_id>trafficgen_cbr_transmitter_0</sink_block_id><source_key>trigger</source_key><sink_key>Trigger Start</sink_key></connection>
<connection><source_block_id>trigger_stop</source_block_id><sink_block_id>trafficgen_cbr_transmitter_0</sink_block_id><source_key>trigger</source_key><sink_key>Trigger Stop</sink_key></connection>
</flow_graph>
