<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>TXOnlyLQE</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>IEEE 802.15.4 Transceiver using OQPSK PHY</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>freq</value></param>
<param><key>choices</key><value>[1000000 * (2400 + 5 * (i - 10)) for i in range(11, 27)]</value></param>
<param><key>value</key><value>2480000000</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Channel</value></param>
<param><key>labels</key><value>[i for i in range(11, 27)]</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>60</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>1</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>50</value></param>
</block>
<block>
<key>blocks_message_strobe_random</key>
<param><key>id</key><value>blocks_message_strobe_random_0</value></param>
<param><key>dist</key><value>blocks.STROBE_POISSON</value></param>
<param><key>mean</key><value>200</value></param>
<param><key>msg</key><value>pmt.intern("TEST22")</value></param>
<param><key>std</key><value>1000</value></param>
</block>
<block>
<key>blocks_pdu_remove</key>
<param><key>id</key><value>blocks_pdu_remove_0</value></param>
<param><key>k</key><value>pmt.intern("es::event_buffer")</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>digital_probe_mpsk_snr_est_c</key>
<param><key>id</key><value>digital_probe_mpsk_snr_est_c_0</value></param>
<param><key>alpha</key><value>0.001</value></param>
<param><key>msg_nsamples</key><value>1000</value></param>
<param><key>type</key><value>2</value></param>
</block>
<block>
<key>es_handler_pdu</key>
<param><key>id</key><value>es_handler_pdu_0</value></param>
<param><key>dt</key><value>es.es_handler_print.TYPE_C32</value></param>
</block>
<block>
<key>es_sink</key>
<param><key>id</key><value>es_sink_0</value></param>
<param><key>eb</key><value>discard</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nthreads</key><value>8</value></param>
<param><key>num_streams</key><value>1</value></param>
<param><key>ss</key><value>binary</value></param>
<param><key>samplehistory</key><value>64</value></param>
<param><key>cb</key><value>drop</value></param>
</block>
<block>
<key>es_trigger_sample_timer</key>
<param><key>id</key><value>es_trigger_sample_timer_0</value></param>
<param><key>length</key><value>512</value></param>
<param><key>period</key><value>int(2000)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>2</value></param>
<param><key>sched_dist</key><value>int(4000000)</value></param>
</block>
<block>
<key>foo_periodic_msg_source</key>
<param><key>id</key><value>foo_periodic_msg_source_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>msg</key><value>pmt.intern("Teste08-2018")</value></param>
<param><key>num</key><value>50</value></param>
<param><key>interval</key><value>100</value></param>
<param><key>quit</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2480000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>ieee802_15_4_mac</key>
<param><key>id</key><value>ieee802_15_4_mac_0</value></param>
<param><key>debug</key><value>True</value></param>
</block>
<block>
<key>ieee802_15_4_oqpsk_phy</key>
<param><key>id</key><value>ieee802_15_4_oqpsk_phy_0</value></param>
</block>
<block>
<key>ieee802_15_4_rime_stack</key>
<param><key>id</key><value>ieee802_15_4_rime_stack_0</value></param>
<param><key>bc_channels</key><value>[129]</value></param>
<param><key>rime_add</key><value>[23,42]</value></param>
<param><key>ruc_channels</key><value>[132]</value></param>
<param><key>uc_channels</key><value>[131]</value></param>
</block>
<block>
<key>lqe_contador</key>
<param><key>id</key><value>lqe_contador_0</value></param>
<param><key>maxValor</key><value>500</value></param>
</block>
<block>
<key>lqe_getRSSI</key>
<param><key>id</key><value>lqe_getRSSI_0</value></param>
<param><key>alphaHW</key><value>0.2</value></param>
<param><key>betaHW</key><value>0.1</value></param>
<param><key>filters</key><value>2</value></param>
<param><key>gammaHW</key><value>0.05</value></param>
<param><key>method</key><value>4</value></param>
<param><key>maxRSSI</key><value>-56</value></param>
<param><key>minRSSI</key><value>-100</value></param>
<param><key>window</key><value>40</value></param>
<param><key>printPower</key><value>False</value></param>
</block>
<block>
<key>lqe_powerControl</key>
<param><key>id</key><value>lqe_powerControl_0</value></param>
<param><key>filenameG</key><value>/home/wendley/SerieGanho100ms.txt</value></param>
<param><key>igtx</key><value>60</value></param>
<param><key>randomGain</key><value>False</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>This is for loopback testing. Disable this block an enable the USRP blocks for over-the-air transmission.</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>you can connect to the Socket PDU with: 'nc -u localhost 52002'</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>numMsg</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>trafficgen_generator_constant</key>
<param><key>id</key><value>trafficgen_generator_constant_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>vbr_port</key><value>trafficgen.VBR_PORT_REQUEST_PACKET_INTERVAL</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>trafficgen_generator_gaussian</key>
<param><key>id</key><value>trafficgen_generator_gaussian_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>mean</key><value>0.5</value></param>
<param><key>multiplier</key><value>1000</value></param>
<param><key>std</key><value>0.1</value></param>
<param><key>vbr_port</key><value>trafficgen.VBR_PORT_REQUEST_BURST_DURATION</value></param>
</block>
<block>
<key>trafficgen_generator_poisson</key>
<param><key>id</key><value>trafficgen_generator_poisson_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>mean</key><value>0.5</value></param>
<param><key>multiplier</key><value>1000</value></param>
<param><key>vbr_port</key><value>trafficgen.VBR_PORT_PACKET_SIZE</value></param>
</block>
<block>
<key>trafficgen_generator_uniform</key>
<param><key>id</key><value>trafficgen_generator_uniform_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>maximum</key><value>0.3</value></param>
<param><key>minimum</key><value>0</value></param>
<param><key>multiplier</key><value>1000</value></param>
<param><key>vbr_port</key><value>trafficgen.VBR_PORT_BURST_INTERVAL</value></param>
</block>
<block>
<key>trafficgen_receiver</key>
<param><key>id</key><value>trafficgen_receiver_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>logfile</key><value>/tmp/trafficgen_receiver.log</value></param>
</block>
<block>
<key>trafficgen_vbr_transmitter</key>
<param><key>id</key><value>trafficgen_vbr_transmitter_0_0</value></param>
<param><key>constant_value</key><value>0</value></param>
<param><key>content_type</key><value>trafficgen.CONTENT_CONSTANT</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>logfile</key><value>/tmp/trafficgen_vbr_transmitter.log</value></param>
<param><key>sequential_maximum</key><value>255</value></param>
<param><key>sequential_minimum</key><value>0</value></param>
<param><key>use_acks</key><value>True</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>4000000</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>4000000</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>uhdgps_cpdu_average_power</key>
<param><key>id</key><value>uhdgps_cpdu_average_power_0</value></param>
<param><key>k</key><value>-60</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>ieee802_15_4_rime_stack_0</sink_block_id><source_key>strobe</source_key><sink_key>bcin</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>lqe_getRSSI_0</sink_block_id><source_key>strobe</source_key><sink_key>sendOrder</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_random_0</source_block_id><sink_block_id>lqe_contador_0</sink_block_id><source_key>strobe</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_pdu_remove_0</source_block_id><sink_block_id>ieee802_15_4_mac_0</sink_block_id><source_key>pdus</source_key><sink_key>cs in</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0_0</source_block_id><sink_block_id>ieee802_15_4_rime_stack_0</sink_block_id><source_key>pdus</source_key><sink_key>bcin</sink_key></connection>
<connection><source_block_id>digital_probe_mpsk_snr_est_c_0</source_block_id><sink_block_id>lqe_getRSSI_0</sink_block_id><source_key>snr</source_key><sink_key>SNR</sink_key></connection>
<connection><source_block_id>es_handler_pdu_0</source_block_id><sink_block_id>uhdgps_cpdu_average_power_0</sink_block_id><source_key>pdus_out</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>es_trigger_sample_timer_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_trigger_sample_timer_0</source_block_id><sink_block_id>es_handler_pdu_0</sink_block_id><source_key>sample_timer_event</source_key><sink_key>handle_event</sink_key></connection>
<connection><source_block_id>es_trigger_sample_timer_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>which_stream</source_key><sink_key>schedule_event</sink_key></connection>
<connection><source_block_id>foo_periodic_msg_source_0</source_block_id><sink_block_id>ieee802_15_4_rime_stack_0</sink_block_id><source_key>out</source_key><sink_key>bcin</sink_key></connection>
<connection><source_block_id>ieee802_15_4_mac_0</source_block_id><sink_block_id>lqe_getRSSI_0</sink_block_id><source_key>ackOut</source_key><sink_key>Ackin</sink_key></connection>
<connection><source_block_id>ieee802_15_4_mac_0</source_block_id><sink_block_id>lqe_powerControl_0</sink_block_id><source_key>ackOut</source_key><sink_key>saveGain</sink_key></connection>
<connection><source_block_id>ieee802_15_4_mac_0</source_block_id><sink_block_id>ieee802_15_4_rime_stack_0</sink_block_id><source_key>app out</source_key><sink_key>fromMAC</sink_key></connection>
<connection><source_block_id>ieee802_15_4_mac_0</source_block_id><sink_block_id>lqe_getRSSI_0</sink_block_id><source_key>packLost</source_key><sink_key>lostPacks</sink_key></connection>
<connection><source_block_id>ieee802_15_4_mac_0</source_block_id><sink_block_id>ieee802_15_4_oqpsk_phy_0</sink_block_id><source_key>pdu out</source_key><sink_key>txin</sink_key></connection>
<connection><source_block_id>ieee802_15_4_mac_0</source_block_id><sink_block_id>lqe_getRSSI_0</sink_block_id><source_key>resendPck</source_key><sink_key>sendPacks</sink_key></connection>
<connection><source_block_id>ieee802_15_4_mac_0</source_block_id><sink_block_id>lqe_powerControl_0</sink_block_id><source_key>resendPck</source_key><sink_key>saveGain</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>ieee802_15_4_mac_0</sink_block_id><source_key>rxout</source_key><sink_key>pdu in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_rime_stack_0</source_block_id><sink_block_id>blocks_socket_pdu_0_0</sink_block_id><source_key>bcout</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ieee802_15_4_rime_stack_0</source_block_id><sink_block_id>ieee802_15_4_mac_0</sink_block_id><source_key>toMAC</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>lqe_contador_0</source_block_id><sink_block_id>ieee802_15_4_rime_stack_0</sink_block_id><source_key>out</source_key><sink_key>bcin</sink_key></connection>
<connection><source_block_id>lqe_contador_0</source_block_id><sink_block_id>lqe_getRSSI_0</sink_block_id><source_key>out</source_key><sink_key>sendOrder</sink_key></connection>
<connection><source_block_id>lqe_getRSSI_0</source_block_id><sink_block_id>lqe_powerControl_0</sink_block_id><source_key>estimation</source_key><sink_key>estimation</sink_key></connection>
<connection><source_block_id>trafficgen_generator_constant_0_0</source_block_id><sink_block_id>trafficgen_vbr_transmitter_0_0</sink_block_id><source_key>Value</source_key><sink_key>Packet Interval</sink_key></connection>
<connection><source_block_id>trafficgen_generator_gaussian_0_0</source_block_id><sink_block_id>trafficgen_vbr_transmitter_0_0</sink_block_id><source_key>Value</source_key><sink_key>Burst Duration</sink_key></connection>
<connection><source_block_id>trafficgen_generator_poisson_0_0</source_block_id><sink_block_id>trafficgen_vbr_transmitter_0_0</sink_block_id><source_key>Value</source_key><sink_key>Packet Size</sink_key></connection>
<connection><source_block_id>trafficgen_generator_uniform_0_0</source_block_id><sink_block_id>trafficgen_vbr_transmitter_0_0</sink_block_id><source_key>Value</source_key><sink_key>Burst Interval</sink_key></connection>
<connection><source_block_id>trafficgen_vbr_transmitter_0_0</source_block_id><sink_block_id>trafficgen_receiver_0</sink_block_id><source_key>PDU</source_key><sink_key>input</sink_key></connection>
<connection><source_block_id>trafficgen_vbr_transmitter_0_0</source_block_id><sink_block_id>trafficgen_generator_constant_0_0</sink_block_id><source_key>Request</source_key><sink_key>Request</sink_key></connection>
<connection><source_block_id>trafficgen_vbr_transmitter_0_0</source_block_id><sink_block_id>trafficgen_generator_gaussian_0_0</sink_block_id><source_key>Request</source_key><sink_key>Request</sink_key></connection>
<connection><source_block_id>trafficgen_vbr_transmitter_0_0</source_block_id><sink_block_id>trafficgen_generator_poisson_0_0</sink_block_id><source_key>Request</source_key><sink_key>Request</sink_key></connection>
<connection><source_block_id>trafficgen_vbr_transmitter_0_0</source_block_id><sink_block_id>trafficgen_generator_uniform_0_0</sink_block_id><source_key>Request</source_key><sink_key>Request</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>digital_probe_mpsk_snr_est_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>es_trigger_sample_timer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>ieee802_15_4_oqpsk_phy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhdgps_cpdu_average_power_0</source_block_id><sink_block_id>blocks_pdu_remove_0</sink_block_id><source_key>cpdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>uhdgps_cpdu_average_power_0</source_block_id><sink_block_id>lqe_getRSSI_0</sink_block_id><source_key>rssi</source_key><sink_key>RSSIin</sink_key></connection>
</flow_graph>
